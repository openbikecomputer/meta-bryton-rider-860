FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-board-Add-support-for-Bryton-Rider-860.patch"
