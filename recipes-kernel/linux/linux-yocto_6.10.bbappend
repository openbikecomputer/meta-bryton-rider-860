FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
#SRC_URI += " \
#    file://defconfig \
#"

COMPATIBLE_MACHINE += "|bryton-rider-860"
